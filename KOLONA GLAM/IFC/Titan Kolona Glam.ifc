Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-07-20T13:24:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 20 13:24:26 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{E29C6AB1-6475-4D9C-9BD2-A82665DE57C7}\ifc * Database version: 5507 * Database creation date: Tue Jul 20 13:24:25 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 20 13:24:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 20 13:24:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: 35x30x180, Titan Kolona glam_R18:35x30x180:380102
In: Level 1
Type - ElementType: 35x30x180; Material: AQ_Crna MDF, AQ_Staklo
Type - Identity Data - Boja: crna; Izradio: Intelika d.o.o.; Manufacturer: Aquaestil; Materijal: Astone, plastificirani čelik, MDF; Model: KOLONA TITAN GLAM; Mogućnost ugradnje: na zid; Type Name: 35x30x180; Web adresa: https://www.aquaestil.hr/hr/proizvodi/titan-premium-linija/kupaonski-namjestaj-titan/25-.html
Type - Materials and Finishes - Materijal konstrukcija: AQ_Crna MDF; Materijal polica: AQ_Staklo
Type - Other - Category: Furniture; Family Name: Titan Kolona glam_R18
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.034 m2; Visina ugradnje: 1200 mm; Volume: 0.00646732 m3
Other - Family: Titan Kolona glam_R18: 35x30x180; Family and Type: Titan Kolona glam_R18: 35x30x180; Type: Titan Kolona glam_R18: 35x30x180; Type Id: Titan Kolona glam_R18: 35x30x180
Phasing - Phase Created: New Construction
